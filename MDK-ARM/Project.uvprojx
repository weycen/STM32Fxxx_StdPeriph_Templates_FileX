# Keil uVision project Project.uvprojx, settings and files
target STM32F072 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F072 +hex
  AfterMake: fromelf --bin -o ".\STM32F072\Output\@L.bin" .\STM32F072\Objects\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072,USE_DEFAULT_TIMEOUT_CALLBACK, FX_INCLUDE_USER_DEFINE_FILE
  c misc: --C99
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\USER_STM32F0xx;..\;D:\WeyWare_C_Series-1.0.0.0\periphlib\stm32\gpio;D:\ztxh_swlib\driverlib;..\Libraries\filex-6.1.7\driver;..\Libraries\filex-6.1.7\common\inc;..\Libraries\filex-6.1.7\ports\cortex_m0\gnu\inc;..\Driverlib;D:\WeyWare_C_Series-1.0.0.0\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Main
    ../: main.c main.h fx_user.h
  group Driverlib
    D:/ztxh_swlib/driverlib/: led.c led.h asmdelay.c asmdelay.h uartstdio.c uartstdio.h
    D:/WeyWare_C_Series-1.0.0.0/periphlib/stm32/gpio/: periph_f0xx_gpio.h periph_f4xx_gpio.h
    D:/WeyWare_C_Series-1.0.0.0/periphlib/stm32/interrupt/: periph_f0xx_interrupt.c periph_f0xx_interrupt.h periph_f4xx_interrupt.c periph_f4xx_interrupt.h
    ../Driverlib/: periph_f0xx_uart.c periph_f0xx_uart.h periph_f1xx_uart.c periph_f1xx_uart.h periph_f4xx_uart.c periph_f4xx_uart.h
  group User/STM32F0xx
    ../USER_STM32F0xx/: readme.txt stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h
  group User/STM32F1xx
    ../USER_STM32F1xx/: readme.txt stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h stm3210c_eval.c stm3210c_eval.h stm32_eval_legacy.h
    ../Libraries/filex-6.1.7/driver/: stm32_spi_sd.c stm32_spi_sd.h
  group User/STM32F4xx
    ../USER_STM32F4xx/: readme.txt stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h stm324xg_eval.c stm324xg_eval.h stm32_eval_legacy.h
    ../Libraries/filex-6.1.7/driver/: stm32_sdio_sd.c stm32_sdio_sd.h
  group CMSIS/STM32F0xx
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group CMSIS/STM32F1xx
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../Libraries/CMSIS/Device/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Libraries/CMSIS/Device/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS/STM32F4xx
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriphDriver/STM32F0xx
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dbgmcu.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_pwr.c
  group StdPeriphDriver/STM32F1xx
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_dma.c
  group StdPeriphDriver/STM32F4xx
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_i2c.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_syscfg.c
  group filex-6.1.7/src
    ../Libraries/filex-6.1.7/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get.c fx_directory_default_get_copy.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_exFAT_entry_read.c fx_directory_exFAT_entry_write.c fx_directory_exFAT_free_search.c fx_directory_exFAT_unicode_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get.c fx_directory_local_path_get_copy.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get.c fx_directory_long_name_get_extended.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get.c fx_directory_short_name_get_extended.c fx_fault_tolerant_add_bitmap_log.c fx_fault_tolerant_add_checksum_log.c fx_fault_tolerant_add_dir_log.c fx_fault_tolerant_add_FAT_log.c fx_fault_tolerant_apply_logs.c fx_fault_tolerant_calculate_checksum.c fx_fault_tolerant_cleanup_FAT_chain.c fx_fault_tolerant_create_log_file.c fx_fault_tolerant_enable.c fx_fault_tolerant_read_directory_sector.c fx_fault_tolerant_read_FAT.c fx_fault_tolerant_read_log_file.c fx_fault_tolerant_recover.c fx_fault_tolerant_reset_log_file.c fx_fault_tolerant_set_FAT_chain.c fx_fault_tolerant_transaction_end.c fx_fault_tolerant_transaction_fail.c fx_fault_tolerant_transaction_start.c fx_fault_tolerant_write_log_file.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate.c fx_file_extended_truncate_release.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate.c fx_file_truncate_release.c fx_file_write.c fx_file_write_notify_set.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_close.c fx_media_close_notify_set.c fx_media_exFAT_format.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_open.c fx_media_open_notify_set.c fx_media_read.c fx_media_space_available.c fx_media_volume_get.c fx_media_volume_get_extended.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_ram_driver.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_trace_event_insert.c fx_trace_event_update.c fx_trace_object_register.c fx_trace_object_unregister.c fx_unicode_directory_create.c fx_unicode_directory_entry_change.c fx_unicode_directory_entry_read.c fx_unicode_directory_rename.c fx_unicode_directory_search.c fx_unicode_file_create.c fx_unicode_file_rename.c fx_unicode_length_get.c fx_unicode_length_get_extended.c fx_unicode_name_get.c fx_unicode_name_get_extended.c fx_unicode_short_name_get.c fx_unicode_short_name_get_extended.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_absolute_path_get.c fx_utility_exFAT_allocate_new_cluster.c fx_utility_exFAT_bitmap_cache_prepare.c fx_utility_exFAT_bitmap_cache_update.c fx_utility_exFAT_bitmap_flush.c fx_utility_exFAT_bitmap_free_cluster_find.c fx_utility_exFAT_bitmap_initialize.c fx_utility_exFAT_bitmap_start_sector_get.c fx_utility_exFAT_cluster_free.c fx_utility_exFAT_cluster_state_get.c fx_utility_exFAT_cluster_state_set.c fx_utility_exFAT_geometry_check.c fx_utility_exFAT_name_hash_get.c fx_utility_exFAT_size_calculate.c fx_utility_exFAT_system_area_checksum_verify.c fx_utility_exFAT_system_area_checksum_write.c fx_utility_exFAT_system_area_format.c fx_utility_exFAT_system_sector_write.c fx_utility_exFAT_unicode_name_hash_get.c fx_utility_exFAT_upcase_table.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c fxe_directory_attributes_read.c fxe_directory_attributes_set.c fxe_directory_create.c fxe_directory_default_get.c fxe_directory_default_get_copy.c fxe_directory_default_set.c fxe_directory_delete.c fxe_directory_first_entry_find.c fxe_directory_first_full_entry_find.c fxe_directory_information_get.c fxe_directory_local_path_clear.c fxe_directory_local_path_get.c fxe_directory_local_path_get_copy.c fxe_directory_local_path_restore.c fxe_directory_local_path_set.c fxe_directory_long_name_get.c fxe_directory_long_name_get_extended.c fxe_directory_name_test.c fxe_directory_next_entry_find.c fxe_directory_next_full_entry_find.c fxe_directory_rename.c fxe_directory_short_name_get.c fxe_directory_short_name_get_extended.c fxe_fault_tolerant_enable.c fxe_file_allocate.c fxe_file_attributes_read.c fxe_file_attributes_set.c fxe_file_best_effort_allocate.c fxe_file_close.c fxe_file_create.c fxe_file_date_time_set.c fxe_file_delete.c fxe_file_extended_allocate.c fxe_file_extended_best_effort_allocate.c fxe_file_extended_relative_seek.c fxe_file_extended_seek.c fxe_file_extended_truncate.c fxe_file_extended_truncate_release.c fxe_file_open.c fxe_file_read.c fxe_file_relative_seek.c fxe_file_rename.c fxe_file_seek.c fxe_file_truncate.c fxe_file_truncate_release.c fxe_file_write.c fxe_file_write_notify_set.c fxe_media_abort.c fxe_media_cache_invalidate.c fxe_media_check.c fxe_media_close.c fxe_media_close_notify_set.c fxe_media_exFAT_format.c fxe_media_extended_space_available.c fxe_media_flush.c fxe_media_format.c fxe_media_open.c fxe_media_open_notify_set.c fxe_media_read.c fxe_media_space_available.c fxe_media_volume_get.c fxe_media_volume_get_extended.c fxe_media_volume_set.c fxe_media_write.c fxe_system_date_get.c fxe_system_date_set.c fxe_system_time_get.c fxe_system_time_set.c fxe_unicode_directory_create.c fxe_unicode_directory_rename.c fxe_unicode_file_create.c fxe_unicode_file_rename.c fxe_unicode_name_get.c fxe_unicode_name_get_extended.c fxe_unicode_short_name_get.c fxe_unicode_short_name_get_extended.c
  group filex-6.1.7/inc
    ../Libraries/filex-6.1.7/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group filex-6.1.7/ports/cm4
    ../Libraries/filex-6.1.7/ports/cortex_m4/gnu/inc/: fx_port.h
    ../Libraries/filex-6.1.7/ports/cortex_m4/: fx_stm32_sd_driver.c fx_stm32_sd_driver.h
  group filex-6.1.7/ports/cm3
    ../Libraries/filex-6.1.7/ports/cortex_m3/gnu/inc/: fx_port.h
    ../Libraries/filex-6.1.7/ports/cortex_m3/: fx_stm32_sd_driver.c fx_stm32_sd_driver.h
target STM32F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  AfterMake: fromelf --bin -o ".\STM32F103\Output\@L.bin" .\STM32F103\Objects\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_DEFAULT_TIMEOUT_CALLBACK, USE_FULL_ASSERT, FX_INCLUDE_USER_DEFINE_FILE
  c misc: --C99
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\Device\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER_STM32F1xx;..\driverlib;..\;D:\ztxh_swlib\driverlib;..\Libraries\filex-6.1.7\common\inc;..\Libraries\filex-6.1.7\ports\cortex_m3\gnu\inc;..\Libraries\filex-6.1.7\ports\cortex_m3;..\Libraries\filex-6.1.7\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
target STM32F407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407
  AfterMake: fromelf --bin -o ".\STM32F407\Output\@L.bin" .\STM32F407\Objects\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, USE_DEFAULT_TIMEOUT_CALLBACK, FX_INCLUDE_USER_DEFINE_FILE
  c misc: --C99
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\USER_STM32F4xx;D:\ztxh_swlib\driverlib;..\;D:\WeyWare_C_Series-1.0.0.0\periphlib\stm32\gpio;D:\WeyWare_C_Series-1.0.0.0\utils;..\Driverlib;..\Libraries\filex-6.1.7\common\inc;..\Libraries\filex-6.1.7\ports\cortex_m4\gnu\inc;..\Libraries\filex-6.1.7\ports\cortex_m4;..\Libraries\filex-6.1.7\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
